# Repository arjepsen/Pedalboard-integrated-audio

File README.md:

# Open Guitar Processing Platform.

A custom Raspberry Pi Compute Module 5 guitar-processing platform with integrated low-latency audio and a separate ESP32-S3 user-interface board.

The project is derived from various other similar projects:
https://github.com/pedalboard
https://rerdavies.github.io/pipedal/
https://www.treefallsound.com/

The hardware has been substantially redesigned around an integrated TAC5212 audio codec, CM5, and a separate UI controller.

The primary software target is the **pi-Stomp / MOD** stack. **PiPedal** is intended as an alternative audio environment using the same hardware.

## Design goals

The main priorities are:

1. Low audio latency
2. High audio quality and low noise
3. Simple hardware where additional complexity provides no meaningful benefit
4. Clean separation of switching, digital, and sensitive analog circuitry
5. Practical manufacture and assembly through JLCPCB
6. Straightforward hand assembly of parts that are impractical or unnecessarily expensive to have assembled

## System architecture

The system is split between two PCBs.

### Mainboard

The mainboard contains the complete audio and compute system:

- Raspberry Pi Compute Module 5
- TAC5212 stereo audio codec
- OPA1656 high-impedance guitar input front end
- Balanced line input
- Dedicated stereo headphone output
- Stereo line/amp output
- TLVM13660 main 5 V power supply
- Low-noise analog power supply
- Codec power supplies
- USB service/recovery connection
- External USB host connection
- Power and UART connection to the UI board

The mainboard is a **four-layer PCB**.

### UI board

The physical controls and display are moved to a separate PCB based on:

- ESP32-S3-WROOM-1U-N8R2
- 3.5-inch SPI TFT display
- Four rotary encoders with push switches
- Four footswitch inputs
- One expression-pedal input
- Up to four indicator LEDs
- Optional chassis-wired MIDI input/output
- Local 3.3 V power supply

The UI board receives 5 V from the mainboard.

Communication between the CM5 and ESP32-S3 uses **UART**. There is no USB connection between the CM5 and UI controller.

The CM5 can also control ESP32-S3 reset and boot mode through the UI interconnect.

## Software architecture

### Primary environment

The primary target is the **pi-Stomp** software environment using:

- MOD-UI
- mod-host
- JACK
- LV2 plugins
- Neural Amp Modeler compatible processing

The intention is to retain the useful pi-Stomp interaction model while adapting it to the custom hardware.

### Alternative environment

**PiPedal** is intended to run as an alternative software environment on the same hardware.

MOD and PiPedal are not intended to operate simultaneously. The system will select which audio environment is active.

### Division of responsibilities

The **CM5** handles:

- Audio processing
- Plugin hosting
- Audio-engine control
- Presets and pedalboards
- System state
- Parameter state
- Communication with the TAC5212
- Communication with the UI controller

The **ESP32-S3** handles:

- Display rendering
- Rotary encoders
- Encoder push switches
- Footswitches
- Expression-pedal sampling
- Indicator LEDs
- Optional future MIDI handling
- Sending user commands to the CM5

The CM5 sends state changes to the ESP32-S3 rather than rendering the user interface (The display) itself.

## Audio architecture

The audio system is built around the **TI TAC5212** codec.

The normal operating point is:

- 48 kHz sample rate
- Stereo I2S
- 32-bit slots
- CM5 as I2S clock producer
- TAC5212 as clock consumer
- No separate audio master-clock oscillator
- Low-latency TAC5212 ADC and DAC filter modes

### Guitar input

Input channel 1 is intended for passive electric guitar pickups.

An **OPA1656** provides the high-impedance input stage and converts the guitar signal to the differential signal required by the TAC5212.

The design provides approximately 1 MΩ guitar input impedance and includes selectable input gain.

The codec input is AC-coupled.

### Line input

Input channel 2 provides a balanced line-level input.

It is AC-coupled into the second differential TAC5212 ADC input.

### Outputs

The system provides:

- Dedicated stereo headphone output
- Stereo unbalanced line/amp output

The TAC5212's output capabilities are used directly where practical in order to avoid unnecessary additional analog stages.

## Power architecture

The board accepts an external DC supply and generates the required system rails locally.

The main power path consists of:

1. Input protection
2. Reverse-polarity protection
3. TLVM13660 switching regulator
4. Main 5 V system rail

The 5 V rail supplies the CM5 and the downstream power systems.

Separate low-noise supplies are used where appropriate for sensitive analog and codec circuitry.

The analog guitar front end uses a quiet higher-voltage rail to provide adequate signal headroom.

The UI board receives 5 V from the mainboard and generates its own local 3.3 V supply.

Power-supply layout, switching-current loops, grounding, thermal performance, and separation from the analog signal path are treated as critical PCB-layout requirements.

## Mainboard / UI connection

The mainboard and UI board use a keyed 10-pin connection carrying:

| Signal | Function |
|---|---|
| +5V_UI | UI-board power |
| GND | Power/signal return |
| CM5_UART_TX | CM5 to ESP32-S3 data |
| CM5_UART_RX | ESP32-S3 to CM5 data |
| UI_RESET_REQ | ESP32-S3 reset request |
| UI_BOOT_REQ | ESP32-S3 boot-mode request |

Multiple 5 V and ground contacts are used in the connector.

The connection is intended to use a short ribbon cable between the two boards.

## USB

USB is kept separate from the UI-controller connection.

The CM5 provides a USB service connection for functions including:

- CM5 recovery / eMMC flashing
- Wired system access
- USB networking

An external USB host connection is also retained.

The ESP32-S3 UI board does not require a USB connection to the CM5.

## MIDI

MIDI is not required for the initial build.

The UI design is intended to preserve the possibility of adding MIDI later without requiring another mainboard revision.

If implemented, MIDI connectors will be chassis-mounted and wired to dedicated connection points on the UI board, rather than placing large DIN/TRS connectors directly on the PCB.

## Mechanical design

The system is intended for installation in an aluminium pedal enclosure.

The mainboard carries the CM5 and audio electronics.

The separate UI board sits beneath the top panel and carries the display, footswitches and rotary controls.

The design must provide sufficient cooling for the CM5. A heatsink and fan are expected, with enclosure ventilation provided as necessary.

The use of a separate UI PCB reduces congestion around the CM5 and allows the display and controls to be positioned according to the enclosure rather than the mainboard layout.

## PCB design

The mainboard uses a **four-layer stackup**.

Important layout priorities include:

- Continuous low-impedance ground
- Small switching-regulator current loops
- Correct TLVM13660 thermal layout
- Separation of the switching supply from sensitive audio circuitry
- Short codec analog paths
- Short local decoupling connections
- Controlled digital return paths
- Sensible separation of CM5, power, codec, and analog regions
- Appropriate USB differential routing
- Good thermal paths for the CM5 and power supply

The PCB is intended for manufacture and partial assembly by **JLCPCB**.

Where performance is equivalent, readily available and economical assembly parts are preferred. More expensive or manually fitted components are used where they provide a meaningful electrical, mechanical, or sourcing advantage.

## Current status

The project is currently in the mainboard PCB-layout stage.

The major mainboard architecture and audio topology have been established.

Current work includes:

- Component placement and floorplanning
- TLVM13660 routing and thermal-via implementation
- Power-distribution layout
- Analog/digital partitioning
- Ground and return-current planning
- Final verification of the mainboard before manufacture

The separate ESP32-S3 UI PCB will be designed after the mainboard architecture and mechanical relationship between the two boards are sufficiently settled.

Because this is intended as a one-off build rather than an iterative prototype programme, schematic and PCB decisions are being reviewed carefully before manufacture.

## Repository structure

The main KiCad project contains the CM5, audio, power, and external-connectivity hardware.

Important documentation is kept under `Docs/`, including:

- `project-status.md` — current project state
- `decisions.md` — established design decisions and their reasoning
- `design-notes.md` — detailed engineering notes
- `work-log.md` — chronological record of completed work
- `mainboard-ui-transition-plan.md` — transition from the former integrated controller to the separate ESP32-S3 UI architecture

The UI PCB is intended to remain part of this repository as a separate KiCad project so that the two boards, their interconnect, and their firmware interface can be versioned together.

## Project history

This project began as a modification of the Open Pedalboard hardware.

The design has since moved substantially beyond the original architecture, including:

- CM5-only compute platform
- Integrated TAC5212 audio codec
- Custom high-impedance guitar front end
- Revised audio outputs
- Revised power architecture
- Four-layer PCB
- TLVM13660 main supply
- Separate ESP32-S3 UI controller
- UART-based CM5/UI communication
- pi-Stomp/MOD as the primary software direction

The original Open Pedalboard project remains an important hardware and software reference.

## License

This project is derived from Open Pedalboard hardware.

See the repository license files and the original Open Pedalboard project for applicable licensing information.

## KiCad design pedalboard-hw.kicad_pcb

Parts:
FID1, FID2, FID3, FID4: Fiducial; Fiducial_1.5mm_Mask3mm
H1, H3, H14, H15: MountingHole; MountingHole_2.7mm_M2.5_DIN965

Parts:
C2: 100uF; CP_Radial_D6.3mm_P2.50mm; Manufacturer part NHG
C3, C5: 10uF; C_1210_3225Metric; Manufacturer part C3225X7R1H106KT000E; JLCPCB part C432929
C28, C32: 47uF; C_1210_3225Metric; Manufacturer part GRM32ER71A476ME15L; JLCPCB part C415541
C30: 22pF; C_0402_1005Metric; Manufacturer part 0402CG220J500NT; JLCPCB part C1555
C53: 4.7uF; C_1812_4532Metric; Manufacturer part 35MU475KC44532
C54, C55: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Manufacturer part CL32B226KAJNNNE; JLCPCB part C309062
C59: 10uF; C_0603_1608Metric; Manufacturer part CL10A106KP8NNNC; JLCPCB part C19702
C60: 100nF; C_0603_1608Metric; Manufacturer part CC0603KRX7R9BB104; JLCPCB part C14663
C71, C72: 1uF; C_0805_2012Metric; Manufacturer part CL21B105KBFNNNE; JLCPCB part C28323
C80, C82: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Manufacturer part CL32B226KAJNNNE; JLCPCB part C309062; not fitted
F1: PTC 4A 30V; Fuse_2920_7451Metric; Manufacturer part 2920L400/30GR; JLCPCB part C19078761
J6: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal; Manufacturer part 1715022; not fitted
J7: Barrel_Jack_MountingPin; BarrelJack_Wuerth_6941xx301002; Manufacturer part 694106301002
Q1: FDS4435BZ; SO08-E3; Manufacturer part FDS4435BZ
R12: 40.2k; R_0402_1005Metric; Manufacturer part 0402WGF4022TCE; JLCPCB part C25893
R13: 62k; R_0402_1005Metric; Manufacturer part 0402WGF6202TCE; JLCPCB part C37825
R14, R15: 10k; R_0402_1005Metric; Manufacturer part 0402WGF1002TCE; JLCPCB part C25744
R17: 13k; R_0402_1005Metric; Manufacturer part 0402WGF1302TCE; JLCPCB part C25754
R20, R32: 100k; R_0603_1608Metric; Manufacturer part 0603WAF1003T5E; JLCPCB part C25803
R35: 15k; R_0603_1608Metric; Manufacturer part 0603WAF1502T5E; JLCPCB part C22809
R36: 10k; R_0603_1608Metric; Manufacturer part 0603WAF1002T5E; JLCPCB part C25804
TP1: VIN; TestPoint_Pad_D1.5mm
TP2: 10V; TestPoint_Pad_D1.5mm
TP3: CODEC_3V3; TestPoint_Pad_D1.5mm
TP5: Gnd; TestPoint_Pad_D1.5mm
TP6: 5V; TestPoint_Pad_D1.5mm
U6: TLVM13660; B3QFN20_RDL_TEX; Manufacturer part TLVM13660RDLR; JLCPCB part C5219281
U13: LT3042; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm; Manufacturer part LT3042EMSE#PBF; JLCPCB part C69847
U15: TPS7A20; SOT-23-5; Manufacturer part TPS7A2033PDBVR; JLCPCB part C2862740

Connections:
3V3_CODEC: C72.1, TP3.1 (1_1), U15.5 (OUT); also elsewhere on the board
+5VP: C28.1, C30.1, C32.1, C71.1, R12.1, R20.1, TP6.1 (1_1), U6.5 (VLDOIN), U6.8 (VOUT1), U6.9 (VOUT2), U15.1 (IN); also elsewhere on the board
+10V: C54.1, C82.1, R35.1, TP2.1 (1_1), U13.9 (OUTS), U13.10 (OUT); also elsewhere on the board
/Power Supply/5V_PG: R20.2, U6.13 (PG), U15.3 (EN)
/Power Supply/fused: F1.2, Q1.5-8
/Power Supply/polarity_checked: C2.1, C3.1, C5.1, C55.1, C80.1, Q1.1-3, R13.1, TP1.1 (1_1), U6.1 (VIN1), U6.16 (VIN2), U13.1 (IN), U13.2 (IN), U13.3 (EN/UV), U13.6 (PGFB)
/Power Supply/unfused: F1.1, J6.2, J7.2
GND: C2.2, C3.2, C5.2, C28.2, C32.2, C53.2, C54.2, C55.2, C59.2, C60.2, C71.2, C72.2, C80.2, C82.2, J6.1, J7.1, Q1.4, R14.2, R15.1, R17.2, R32.2, R36.1, TP5.1 (1_1), U6.6 (AGND), U6.11 (AGND), U6.17 (PGND), U6.18 (PGND), U6.19 (PGND), U6.20 (PGND), U13.5 (ILIM), U13.8 (GND), U13.11 (GND), U15.2 (GND); also elsewhere on the board
unnamed: R13.2, R14.1, U6.14 (EN)
unnamed: C30.2, R12.2, R15.2, U6.10 (FB)
unnamed: R17.1, U6.12 (RT)
unnamed: C53.1, R32.1, U13.7 (SET)
VBIAS_4V: C59.1, C60.1, R35.2, R36.2; also elsewhere on the board

Notes on the sheet:
load ground
Kelvin SET return: R32 and C53 share this return node. Route it directly to C54 negative/load ground. Do not connect this node to U13 GND or the ground plane before C54−.
5.5mm × 2.1mm, Center Positive
POWER INPUT: 12 VDC regulated, 4 A recommended
Revese Polarity Protection
PCB layout: Place C3/C5 close to VIN and PGND. Place C28/C32 close to VOUT and PGND. Keep R12, R15, C30 and R17 close to U6 and away from noisy power copper.
Kelvin VOUT sense: OUTS is the same electrical net as OUT. Route OUTS separately from pin 9 to the COUT positive/load node, and join OUT there.
4V analog bias
TAC5212 analog power
+5.0V / 6A buck module - regulated 12V input
+10V analog

Parts:
C56: 100nF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C57, C58, C62, C63: 4.7uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Manufacturer part 16MF475KB23225; JLCPCB part C50394238
C61, C65, C66, C70: 100nF; C_0603_1608Metric; Manufacturer part CC0603KRX7R9BB104; JLCPCB part C14663
C67, C68, C79: 10uF; C_0805_2012Metric; Manufacturer part CL21A106KAYNNNE; JLCPCB part C15850
C69: 1uF; C_0805_2012Metric; Manufacturer part CL21B105KBFNNNE; JLCPCB part C28323
C73, C74: 680uF; CP_Radial_D8.0mm_P3.50mm; Manufacturer part EEU-FR1A681
C75, C77: 4.7uF; C_1206_3216Metric; Manufacturer part 1206B475K500NT; JLCPCB part C29823
C76, C78: 2.2nF; C_0603_1608Metric; Manufacturer part 0603B222K500NT; JLCPCB part C1604
C81: 47uF; CP_Radial_D6.3mm_P2.50mm; Manufacturer part ECA1EHG101
CM2: Raspberry Pi CM5; Raspberry-Pi-5-Compute-Module
D3: ESD401; Texas_DPY0002A_0.6x1mm_P0.65mm; Manufacturer part ESD401DPYR; JLCPCB part C1974752
D4, D5, D8, D9: H5VUD5BB; D_SOD-523; Manufacturer part H5VUD5BB; JLCPCB part C20615820
D6: LED Y; LED_0805_2012Metric; Manufacturer part KT-0805Y; JLCPCB part C2296
IC1: TAC5212IRGER; Manufacturer part TAC5212IRGER; JLCPCB part C44853694
J13: Headphones 3.5mm; Jack_3.5mm_CUI_SJ1-3525N_Horizontal; Manufacturer part SJ1-3525N
J18: GUITAR INPUT; Jack_6.35mm_Neutrik_NMJ4HCD2_Horizontal; Manufacturer part NMJ4HCD2
J19: LINE OUT LEFT; Jack_6.35mm_Neutrik_NMJ4HCD2_Horizontal; Manufacturer part NMJ4HCD2
J20: LINE OUT RIGHT; Jack_6.35mm_Neutrik_NMJ4HCD2_Horizontal; Manufacturer part NMJ4HCD2
J22: BALANCED LINE INPUT; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal; Manufacturer part NMJ6HCD2
R16: 1k; R_0805_2012Metric; Manufacturer part 0805W8F1001T5E; JLCPCB part C17513
R33: 1M; R_0603_1608Metric; Manufacturer part 0603WAF1004T5E; JLCPCB part C22935
R34, R37, R40, R57: 1k; R_0603_1608Metric; Manufacturer part 0603WAF1001T5E; JLCPCB part C21190
R38, R39, R47, R49: 470R; R_0603_1608Metric; Manufacturer part 0603WAF4700T5E; JLCPCB part C23179
R41, R42, R48, R50: 100k; R_0603_1608Metric; Manufacturer part 0603WAF1003T5E; JLCPCB part C25803
R43, R44: 7k5; R_0603_1608Metric; Manufacturer part 0603WAF7501T5E; JLCPCB part C23234
R45, R46: 10k; R_0603_1608Metric; Manufacturer part 0603WAF1002T5E; JLCPCB part C25804
R51, R52: 4k7; R_0603_1608Metric; Manufacturer part 0603WAF4701T5E; JLCPCB part C23162
R54, R56: 820R; R_0603_1608Metric; Manufacturer part 0603WAF8200T5E; JLCPCB part C23253
R55: 390R; R_0603_1608Metric; Manufacturer part 0603WAF3900T5E; JLCPCB part C23151
SW11: EM-02-Q; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W8.61mm_P2.54mm_LowProfile; Manufacturer part EM-02-Q; JLCPCB part C501539
U14: OPA1656ID; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer part OPA1656ID; JLCPCB part C1346368

Connections:
3V3_CODEC: C66.1, C67.1, IC1.23 (AVDD); also elsewhere on the board
+5VP: CM2.77 (+5v_(Input)), CM2.79 (+5v_(Input)), CM2.81 (+5v_(Input)), CM2.83 (+5v_(Input)), CM2.85 (+5v_(Input)), CM2.87 (+5v_(Input)); also elsewhere on the board
+10V: C61.1, U14.8 (V+); also elsewhere on the board
/Audio/CM5_LED_ACT: CM2.21 (LED_nACT), D6.1 (K)
/Audio/TAC_IN1M: C57.2, IC1.16 (IN1M)
/Audio/TAC_IN1P: C58.2, IC1.15 (IN1P)
/Audio/TAC_IN2M: IC1.18 (IN2M), R44.1
/Audio/TAC_IN2P: IC1.17 (IN2P), R43.1
/Audio/TAC_OUT1M: C77.1, IC1.19 (OUT1M)
/Audio/TAC_OUT1P: C75.1, IC1.20 (OUT1P)
/Audio/TAC_OUT2M: C74.1, IC1.22 (OUT2M)
/Audio/TAC_OUT2P: C73.1, IC1.21 (OUT2P)
/Audio/audio_pcm_clk: CM2.49 (GPIO18), IC1.2 (BCLK)
/Audio/audio_pcm_din: CM2.27 (GPIO20), IC1.4 (DOUT)
/Audio/audio_pcm_dout: CM2.25 (GPIO21), IC1.5 (DIN)
/Audio/audio_pcm_fs: CM2.26 (GPIO19), IC1.3 (FSYNC)
/Audio/conf_i2c_scl: CM2.56 (GPIO3), IC1.7 (SCL), R52.2
/Audio/conf_i2c_sda: CM2.58 (GPIO2), IC1.8 (SDA), R51.1
CM5_3V: C68.1, C70.1, CM2.78 (GPIO_VREF(1.8v/3.3v_Input)), CM2.84 (+3.3v_(Output)), CM2.86 (+3.3v_(Output)), IC1.6 (IOVDD), R16.2, R51.2, R52.1
CM5_DEBUG_UART_RX: CM2.51 (GPIO15); also elsewhere on the board
CM5_DEBUG_UART_TX: CM2.55 (GPIO14); also elsewhere on the board
CM_BOOT: CM2.93 (nRPIBOOT); also elsewhere on the board
ESP_BOOT: CM2.47 (GPIO23); also elsewhere on the board
ESP_RESET: CM2.46 (GPIO22); also elsewhere on the board
GND: C61.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C76.2, C78.2, C79.2, C81.2, CM2.1 (GND), CM2.2 (GND), CM2.7 (GND), CM2.8 (GND), CM2.13 (GND), CM2.14 (GND), CM2.22 (GND), CM2.23 (GND), CM2.32 (GND), CM2.33 (GND), CM2.42 (GND), CM2.43 (GND), CM2.52 (GND), CM2.53 (GND), CM2.59 (GND), CM2.60 (GND), CM2.65 (GND), CM2.66 (GND), CM2.71 (GND), CM2.74 (GND), CM2.98 (GND), D3.1 (A1), D4.1 (A1), D5.1 (A1), D8.1 (A1), D9.1 (A1), IC1.13 (ADDR), IC1.25 (VSS_1), IC1.A1 (VSS_2), IC1.A2 (VSS_3), IC1.A3 (VSS_4), IC1.A4 (VSS_5), J13.S, J18.S, J18.TN, J19.S, J20.S, J22.RN, J22.S, J22.TN, R41.2, R42.1, R45.2, R46.2, R48.2, R50.2, U14.4 (V-); also elsewhere on the board
unnamed: C57.1, R38.1, R40.1
unnamed: C58.1, R39.1, R40.2
unnamed: C62.1, J22.T, R41.1
unnamed: C62.2, R43.2
unnamed: C63.1, J22.R, R42.2
unnamed: C63.2, R44.2
unnamed: C75.2, R47.2
unnamed: C77.2, R49.2
unnamed: C81.1, R57.2
unnamed: C56.1, D3.2 (A2), J18.T
unnamed: C73.2, D4.2 (A2), J13.T, R45.1
unnamed: C74.2, D5.2 (A2), J13.R, R46.1
unnamed: D6.2 (A), R16.1
unnamed: C78.1, D8.2 (A2), J20.T, R49.1, R50.1
unnamed: C76.1, D9.2 (A2), J19.T, R47.1, R48.1
unnamed: C65.1, C79.1, IC1.1 (DREG)
unnamed: C69.1, IC1.24 (VREF)
unnamed: R34.2, R39.2, R55.1, U14.1
unnamed: R37.1, R38.2, U14.7
unnamed: R54.1, R55.2, SW11.4
unnamed: R54.2, R56.1, SW11.1, SW11.2
unnamed: C56.2, R33.1, U14.3 (+)
unnamed: R56.2, R57.1, SW11.3, U14.2 (-)
unnamed: R34.1, R37.2, U14.6 (-)
UI_UART_RX: CM2.34 (GPIO5); also elsewhere on the board
UI_UART_TX: CM2.54 (GPIO4); also elsewhere on the board
VBIAS_4V: R33.2, U14.5 (+); also elsewhere on the board

Notes on the sheet:
Input gain: 1+2 ON: LOW 1.39x 1 ON, 2 OFF (or reverse): MID 2.21x 1+2 OFF: HIGH 3.03x
U14 supply
Inputs
Activity
CODEC
Outputs

Parts:
C16: 100nF; C_0603_1608Metric; Manufacturer part CC0603KRX7R9BB104; JLCPCB part C14663
C38, C39, C40: 10uF; C_0805_2012Metric; Manufacturer part CL21A106KAYNNNE; JLCPCB part C15850
C43: 100uF; CP_Radial_D8.0mm_P3.50mm; Manufacturer part RR71C101MDN1
C50: 1nF; C_1206_3216Metric; Manufacturer part GRM31C5C3A102JWA3L; JLCPCB part C521240
CM2: Raspberry Pi CM5; Raspberry-Pi-5-Compute-Module
J9: USB-C SERVICE; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; Manufacturer part USB4105-GF-A-120; JLCPCB part C5184243
J10: USB-A HOST; USB_A_Molex_67643_Horizontal; Manufacturer part 67643-3910
J11: CM5 BOOT; PinHeader_1x02_P2.54mm_Vertical
J16: CM5 UART DEBUG; PinHeader_1x03_P2.54mm_Vertical; not fitted
J21: UI LINK 2x5; J_Wurth_WR-BHD_61201021621; Manufacturer part 61201021621
R29: 15k; R_0805_2012Metric; Manufacturer part 0805W8F1502T5E; JLCPCB part C17475
R30, R31: 5k1; R_0402_1005Metric; Manufacturer part 0402WGF5101TCE; JLCPCB part C25905
R53: 1M; R_0603_1608Metric; Manufacturer part 0603WAF1004T5E; JLCPCB part C22935
U10: AP22653; SOT-23-6; Manufacturer part AP22653W6-7; JLCPCB part C2158037
U11, U16: TPD2E2U06QDCKRQ1; SOT-323_SC-70; Manufacturer part TPD2E2U06QDCKRQ1; JLCPCB part C915089

Connections:
+5VP: C16.1, C38.1, J21.1, J21.10, U10.1 (IN); also elsewhere on the board
/Connectivity/USB_HOST_N: CM2.165 (USB3-1-D_N), J10.2 (D-), U11.2
/Connectivity/USB_HOST_P: CM2.163 (USB3-1-D_P), J10.3 (D+), U11.1
/Connectivity/USB_HOST_VBUS_EN: CM2.111 (VBUS_EN), U10.3 (EN)
/Connectivity/USB_SERVICE_N: CM2.103 (USB2_N), J9.A7 (D-), J9.B7 (D-), U16.2
/Connectivity/USB_SERVICE_P: CM2.105 (USB2_P), J9.A6 (D+), J9.B6 (D+), U16.1
/Connectivity/USB_SERVICE_VBUS_UNUSED: J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS)
/Connectivity/VBUS: C39.1, C40.1, C43.1, J10.1 (VBUS), U10.6 (OUT)
CHASSIS: C50.2, J9.SH (SHIELD), J10.SH (Shield), R53.1
CM5_DEBUG_UART_RX: J16.3; also elsewhere on the board
CM5_DEBUG_UART_TX: J16.2; also elsewhere on the board
CM_BOOT: J11.1; also elsewhere on the board
ESP_BOOT: J21.8; also elsewhere on the board
ESP_RESET: J21.3; also elsewhere on the board
GND: C16.2, C38.2, C39.2, C40.2, C43.2, C50.1, CM2.107 (GND), CM2.108 (GND), CM2.113 (GND), CM2.114 (GND), CM2.119 (GND), CM2.120 (GND), CM2.125 (GND), CM2.126 (GND), CM2.131 (GND), CM2.132 (GND), CM2.137 (GND), CM2.138 (GND), CM2.144 (GND), CM2.150 (GND), CM2.155 (GND), CM2.156 (GND), CM2.161 (GND), CM2.162 (GND), CM2.167 (GND), CM2.168 (GND), CM2.173 (GND), CM2.174 (GND), CM2.179 (GND), CM2.180 (GND), CM2.185 (GND), CM2.186 (GND), CM2.191 (GND), CM2.192 (GND), CM2.197 (GND), CM2.198 (GND), J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J10.4 (GND), J11.2, J16.1, J21.2, J21.4, J21.7, J21.9, R29.1, R30.2, R31.2, R53.2, U10.2 (GND), U11.3, U16.3; also elsewhere on the board
unnamed: J9.A5 (CC1), R30.1
unnamed: J9.B5 (CC2), R31.1
unnamed: R29.2, U10.5 (ILIM)
UI_UART_RX: J21.5; also elsewhere on the board
UI_UART_TX: J21.6; also elsewhere on the board

Notes on the sheet:
Optional 3.3V CM5 debug UART. Pin order: GND, TX, RX.
PCB placement: C16 and C38 close to U10 IN/GND. R29 close to ILIM/GND. C39 or C40 close to OUT/GND. C43 near J10 VBUS.
USB-host protection
USB-service protection
Fit manually if required. Install jumper before power-up to force CM5 USB boot mode.
USB
Serial Debug

Board: 4 copper layers, 174.0 x 111.0 mm, 120 parts (0 on the bottom side), 71 nets.

Notices in the files:
pedalboard-hw-layout-work.kicad_pcb:
License: CERN Open Hardware Licence Version 2 - Permissive
