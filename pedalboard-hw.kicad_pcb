# Repository arjepsen/Pedalboard-integrated-audio (continued)

## KiCad design pedalboard-hw-layout-work.kicad_pcb

Board: 2 copper layers, 174.0 x 111.0 mm, 166 parts (3 on the bottom side), 145 nets.

Parts:
C1, C13, C15, C16, C17, C18, C19, C20, C21, C23, C30, C35, C46, C47, C48, C49, C52: 100n; C_0805_2012Metric
C2, C3, C4, C5, C6, C7, C8, C9, C10, C24, C27, C28, C32, C36, C37, C38, C39, C40, C41, C42, C44, C45: 10u; C_0805_2012Metric
C11, C25: 18p; C_0805_2012Metric
C12, C14: 1u; C_0805_2012Metric
C22, C26: 15p; C_0805_2012Metric
C29, C34, C50, C51: 1n; C_0805_2012Metric
C31: 1.2n; C_0805_2012Metric
C33, C43: 100u; CP_EIA-7343-31_Kemet-D
CM1: CM4; Raspberry-Pi-4-Compute-Module
D1: SM4007; D_SOD-123F
D2, D6: LED Y; LED_0805_2012Metric
D7: LED R; LED_0805_2012Metric
F1: Polyfuse 1.8A; Fuse_1812_4532Metric
FID1, FID2, FID3, FID4: Fiducial; Fiducial_1.5mm_Mask3mm
H1, H3, H4, H5, H6, H7, H14, H15, H16: MountingHole; MountingHole_2.7mm_M2.5_DIN965
H2: Midi Bites; MIDI bites
J1, J3: Jack 3.5mm; Jack_3.5mm_CUI_SJ1-3525N_Horizontal
J2, J4: DIN5; CP-2350
J5, J8, J18, J19, J20, J22: Jack 6.35mm; Jack_6.35mm_Horizontal
J6: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J7: Barrel_Jack_MountingPin; BarrelJack_Wuerth_6941xx301002
J9: USB_OTG; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J10: USB_A; USB_A_Molex_67643_Horizontal
J11: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J12, J16: Debug; PinHeader_1x03_P2.54mm_Vertical
J14: JST PH 4; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J25, J26: JST PH 3; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J27: Pedalboard Soundcard; Pedalboard_Soundcard
J28: JST PH 3; JST_PH_B3B-PH-SM4-TB_1x03-1MP_P2.00mm_Vertical
JP1, JP2, JP3, JP4: SJP; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP5, JP6: SJP; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2, L3, L4: 120_100MHz; L_0603_1608Metric
L5: SRN6045TA-3R3Y; L_Bourns_SRN6045TA
Q1: FDS4435BZ; SO08-E3
R1, R2, R8, R11, R16: 1K; R_0805_2012Metric
R3, R7, R20: 220R; R_0805_2012Metric
R4: 33R; R_0805_2012Metric
R5, R13: 10R; R_0805_2012Metric
R6, R10: 27R; R_0805_2012Metric
R9: DNF; R_0805_2012Metric
R12, R24: 12K; R_0805_2012Metric
R14: 20K; R_0805_2012Metric
R15, R17, R21, R22, R23: 2K2; R_0805_2012Metric
R18, R19: 3K9; R_0805_2012Metric
R25, R26, R27, R28, R29: 36K; R_0805_2012Metric
R30, R31: 5K1; R_0402_1005Metric
SW1, SW2: 24P/R 24mm; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMoun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
SW3, SW4: Micro Button; SW_SPST_B3U-1000P
SW5, SW6, SW7, SW8, SW9, SW10: Momentary switch; APEM_8632A_SolderLug
SYM1: Logo_Open_Hardware_Small; OSHW-Logo_7.5x8mm_SilkScreen
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_2.0x2.0mm
U1, U7: 74AHCT1G32SE-7; SOT-353_SC-70-5
U2: TLP2761; SO-6L_10x3.84mm_P1.27mm
U3: RP2040; RP2040-QFN-56
U4: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U5: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U6: AP64501SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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
U8: FSUSB42MUX; TSSOP-10_3x3mm_P0.5mm
U9: USB2514B_Bi; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
U10: AP2553W6; SOT-23-6
U11: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm
U12: AT24CS01-STUM; SOT-23-5
Y1: Crystal_Small; Crystal_SMD_5032-2Pin_5.0x3.2mm
Y2: ABM8-272-T3; ABM8-272-T3_ABR

Connections:
+1V1: C12.1, C16.1, C21.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C13.1, C14.1, C15.1, C17.1, C18.1, C19.1, C20.1, C23.1, C24.1, C52.1, J14.3, R1.1, R2.1, R4.1, R9.1, R18.1, R19.1, U2.6 (VDD), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.8 (VCC), U5.2 (VO), U12.4 (VCC)
+5VP: C27.1, C28.1, C29.1, C32.1, C33.1, C36.1, C37.1, C38.1, CM1.77 (+5v_(Input)), CM1.79 (+5v_(Input)), CM1.81 (+5v_(Input)), CM1.83 (+5v_(Input)), CM1.85 (+5v_(Input)), CM1.87 (+5v_(Input)), J27.2 (5V), J27.4 (5V), J28.2, L5.2, R12.1, TP3.1 (1_1), U1.5 (VCC), U5.3 (VI), U10.1 (IN)
/Audio/CM4_3V: C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, CM1.78 (GPIO_VREF(1.8v/3.3v_Input)), CM1.84 (+3.3v_(Output)), CM1.86 (+3.3v_(Output)), J27.1 (3V3), J27.17 (3V3), R16.2, R17.2, U7.5 (VCC), U8.1 (VCC), U9.5 (VDDA33), U9.10 (VDDA33), U9.15 (VDD33), U9.23 (VDD33), U9.27 (VBUS_DET), U9.29 (VDDA33), U9.36 (VDDA33)
/Audio/CM4_GPIO4: CM1.54 (GPIO4), J27.7 (GCLK0/GPIO4)
/Audio/CM4_GPIO5: CM1.34 (GPIO5), J27.29 (GCLK1/GPIO5)
/Audio/CM4_GPIO6: CM1.30 (GPIO6), J27.31 (GCLK2/GPIO6)
/Audio/CM4_GPIO7: CM1.37 (GPIO7), J27.26 (~CE1/GPIO7)
/Audio/CM4_GPIO8: CM1.39 (GPIO8), J27.24 (~CE0/GPIO8)
/Audio/CM4_GPIO9: CM1.40 (GPIO9), J27.21 (MISO0/GPIO9)
/Audio/CM4_GPIO10: CM1.44 (GPIO10), J27.19 (MOSI0/GPIO10)
/Audio/CM4_GPIO11: CM1.38 (GPIO11), J27.23 (SCLK0/GPIO11)
/Audio/CM4_GPIO12: CM1.31 (GPIO12), J27.32 (PWM0/GPIO12)
/Audio/CM4_GPIO13: CM1.28 (GPIO13), J27.33 (PWM1/GPIO13)
/Audio/CM4_GPIO16: CM1.29 (GPIO16), J27.36 (GPIO16)
/Audio/CM4_GPIO17: CM1.50 (GPIO17), J27.11 (GPIO17)
/Audio/CM4_GPIO22: CM1.46 (GPIO22), J27.15 (GPIO22)
/Audio/CM4_GPIO23: CM1.47 (GPIO23), J27.16 (GPIO23)
/Audio/CM4_GPIO24: CM1.45 (GPIO24), J27.18 (GPIO24)
/Audio/CM4_GPIO25: CM1.41 (GPIO25), J27.22 (GPIO25)
/Audio/CM4_ID_SC: CM1.35 (ID_SC), J27.28 (ID_SC/GPIO1)
/Audio/CM4_ID_SD: CM1.36 (ID_SD), J27.27 (ID_SD/GPIO0)
/Audio/CM4_LED_ACT: CM1.21 (PI_nLED_Activity), D6.1 (K)
/Audio/CM4_LED_PWR: CM1.95 (nPI_LED_PWR), U7.1 (A)
/Audio/GND_in_L: J22.RN, J22.S, J22.TN, J27.44 (in_GND)
/Audio/GND_in_R: J18.RN, J18.S, J18.TN, J27.43 (in_GND)
/Audio/GND_out: J19.S, J20.S, J27.49 (out_GND), J27.50 (out_GND)
/Audio/INT_MIDI_RX: CM1.51 (GPIO15), J16.3, J27.10 (GPIO15/RXD), JP2.1 (A)
/Audio/INT_MIDI_TX: CM1.55 (GPIO14), J16.2, J27.8 (GPIO14/TXD), JP1.1 (A)
/Audio/audio_in_stereo: CM1.48 (GPIO27), J27.13 (GPIO27), JP4.2 (B)
/Audio/audio_out_stereo: CM1.24 (GPIO26), J27.37 (GPIO26), JP3.2 (B)
/Audio/audio_pcm_clk: CM1.49 (GPIO18), J27.12 (GPIO18/PWM0)
/Audio/audio_pcm_din: CM1.27 (GPIO20), J27.38 (GPIO20/MOSI1)
/Audio/audio_pcm_dout: CM1.25 (GPIO21), J27.40 (GPIO21/SCLK1)
/Audio/audio_pcm_fs: CM1.26 (GPIO19), J27.35 (GPIO19/MISO1)
/Audio/conf_i2c_scl: CM1.56 (GPIO3), J27.5 (SCL/GPIO3)
/Audio/conf_i2c_sda: CM1.58 (GPIO2), J27.3 (SDA/GPIO2)
/Audio/in_L+: J22.T, J27.45 (in_L+)
/Audio/in_L-: J22.R, J27.46 (in_L-)
/Audio/in_R+: J18.T, J27.42 (in_R+)
/Audio/in_R-: J18.R, J27.41 (in_R-)
/Audio/nEXTRST: CM1.100 (nEXTRST), U9.26 (RESET_N)
/Connectivity/USB_CM_N: CM1.103 (USB2_N), U8.4 (D-)
/Connectivity/USB_CM_P: CM1.105 (USB2_P), U8.3 (D+)
/Connectivity/USB_D_N: J9.A7 (D-), J9.B7 (D-), U8.8 (HSD2-), U11.5 (D2-), U11.6 (NC)
/Connectivity/USB_D_P: J9.A6 (D+), J9.B6 (D+), U8.9 (HSD2+), U11.4 (D2+), U11.7 (NC)
/Connectivity/USB_OUT_N: J10.2 (D-), U9.3 (USBDM_DN2/PRT_DIS_M2)
/Connectivity/USB_OUT_P: J10.3 (D+), U9.4 (USBDP_DN2/PRT_DIS_P2)
/Connectivity/USB_RP_N: R10.1, U9.1 (USBDM_DN1/PRT_DIS_M1)
/Connectivity/USB_RP_P: R6.1, U9.2 (USBDP_DN1/PRT_DIS_P1)
/Connectivity/USB_UP_N: U8.6 (HSD1-), U9.30 (USBDM_UP)
/Connectivity/USB_UP_P: U8.7 (HSD1+), U9.31 (USBDP_UP)
/Connectivity/VBUS: C39.1, C40.1, C41.1, C42.1, C43.1, J10.1 (VBUS), U10.6 (OUT)
/Connectivity/nOCS1: U9.13 (OCS_N1), U9.17 (OCS_N2), U9.19 (OCS_N3), U9.21 (OCS_N4), U10.4 (nFault)
/LEDs/RGB_DATA: R7.1, U3.14 (GPIO11)
/MIDI/A_EXP1: J5.R, U3.40 (GPIO28_ADC2)
/MIDI/A_EXP2: J8.R, U3.39 (GPIO27_ADC1)
/MIDI/EXT_MIDI_RX: U2.5 (VO), U3.3 (GPIO1)
/MIDI/EXT_MIDI_TX: R5.2, U3.2 (GPIO0)
/MIDI/I2C_SCL: J14.1, R18.2, U3.37 (GPIO25), U12.1 (SCL)
/MIDI/I2C_SDA: J14.2, R19.2, U3.36 (GPIO24), U12.3 (SDA)
/MIDI/QSPI_SCLK: U3.52 (QSPI_SCLK), U4.6 (CLK)
/MIDI/QSPI_SD0: U3.53 (QSPI_SD0), U4.5 (DI(IO0))
/MIDI/QSPI_SD1: U3.55 (QSPI_SD1), U4.2 (DO(IO1))
/MIDI/QSPI_SD2: U3.54 (QSPI_SD2), U4.3 (IO2)
/MIDI/QSPI_SD3: U3.51 (QSPI_SD3), U4.7 (IO3)
/MIDI/QSPI_SS: R8.2, R9.2, U3.56 (QSPI_SS), U4.1 (~CS)
/MIDI/ROT_GAIN_A: SW2.A, U3.30 (GPIO19)
/MIDI/ROT_GAIN_B: SW2.B, U3.31 (GPIO20)
/MIDI/ROT_VOL_A: SW1.A, U3.27 (GPIO16)
/MIDI/ROT_VOL_B: SW1.B, U3.28 (GPIO17)
/MIDI/SWCLK: J12.1, U3.24 (SWCLK)
/MIDI/SWD: J12.3, U3.25 (SWD)
/MIDI/SW_A: SW8.2 (B), U3.8 (GPIO6)
/MIDI/SW_B: SW9.2 (B), U3.7 (GPIO5)
/MIDI/SW_C: SW10.2 (B), U3.4 (GPIO2)
/MIDI/SW_D: SW5.2 (B), U3.9 (GPIO7)
/MIDI/SW_E: SW6.2 (B), U3.6 (GPIO4)
/MIDI/SW_F: SW7.2 (B), U3.5 (GPIO3)
/MIDI/SW_GAIN: SW2.S1, U3.32 (GPIO21)
/MIDI/SW_VOL: SW1.S1, U3.29 (GPIO18)
/MIDI/XIN: C22.1, U3.20 (XIN), Y2.1
/MIDI/XOUT: R11.1, U3.21 (XOUT)
/MIDI/~USB_BOOT: R8.1, SW3.2
/Power Supply/fused: C2.1, C4.1, F1.2, Q1.5-8
/Power Supply/polarity_checked: C3.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, Q1.1-3, TP1.1 (1_1), U6.2 (VIN), U6.3 (EN)
/Power Supply/switch: L5.1, R13.1, U6.8 (SW)
/Power Supply/unfused: F1.1, J6.2, J7.2
CM_BOOT: CM1.93 (nRPIBOOT), J11.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.1, C51.2, C52.2, CM1.1 (GND), CM1.2 (GND), CM1.7 (GND), CM1.8 (GND), CM1.13 (GND), CM1.14 (GND), CM1.22 (GND), CM1.23 (GND), CM1.32 (GND), CM1.33 (GND), CM1.42 (GND), CM1.43 (GND), CM1.52 (GND), CM1.53 (GND), CM1.59 (GND), CM1.60 (GND), CM1.65 (GND), CM1.66 (GND), CM1.71 (GND), CM1.74 (GND), CM1.98 (GND), CM1.107 (GND), CM1.108 (GND), CM1.113 (GND), CM1.114 (GND), CM1.119 (GND), CM1.120 (GND), CM1.125 (GND), CM1.126 (GND), CM1.131 (GND), CM1.132 (GND), CM1.137 (GND), CM1.138 (GND), CM1.144 (GND), CM1.150 (GND), CM1.155 (GND), CM1.156 (GND), CM1.161 (GND), CM1.162 (GND), CM1.167 (GND), CM1.168 (GND), CM1.173 (GND), CM1.174 (GND), CM1.179 (GND), CM1.180 (GND), CM1.185 (GND), CM1.186 (GND), CM1.191 (GND), CM1.192 (GND), CM1.197 (GND), CM1.198 (GND), D2.1 (K), J3.S, J4.2, J5.RN, J5.S, J6.1, J7.1, J8.RN, J8.S, J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J10.4 (GND), J11.2, J12.2, J14.4, J16.1, J26.2, J27.6 (GND), J27.9 (GND), J27.14 (GND), J27.20 (GND), J27.25 (GND), J27.30 (GND), J27.34 (GND), J27.39 (GND), J28.1, Q1.4, R15.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.1, R30.2, R31.2, SW1.C, SW1.S2, SW2.C, SW2.S2, SW3.1, SW4.1, SW5.1 (A), SW6.1 (A), SW7.1 (A), SW8.1 (A), SW9.1 (A), SW10.1 (A), TP2.1 (1_1), U1.2 (B), U1.3 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U4.4 (GND), U5.1 (GND), U6.7 (GND), U6.9 (EP), U7.2 (B), U7.3 (GND), U8.5 (GND), U8.10 (~OE), U9.37 (VSS), U10.2 (GND), U11.3 (GND), U11.8 (GND), U12.2 (GND), U12.5 (WP), Y2.2, Y2.4
unnamed: C26.1, R11.2, Y2.3
unnamed: C30.1, R13.2
unnamed: C31.1, R14.2
unnamed: CM1.101 (USB_OTG_ID), R22.1, R23.1, U8.2 (SEL)
unnamed: D1.2 (A), L1.2, U2.3 (K)
unnamed: D1.1 (K), R3.2, U2.1 (A)
unnamed: D2.2 (A), R21.2, TP4.1 (1_1)
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), R17.1
unnamed: D7.1 (K), U7.4 (Y)
unnamed: J5.T, R1.2
unnamed: J8.T, R2.2
unnamed: J9.A5 (CC1), R30.1
unnamed: J9.B5 (CC2), R31.1
unnamed: C50.2, J9.SH (SHIELD)
unnamed: J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), R22.2
unnamed: C51.1, J10.SH (Shield)
unnamed: J1.R, J1.RN, J2.4, J25.1, L4.1
unnamed: C1.1, J1.S, J2.2, J25.2
unnamed: J1.T, J1.TN, J2.5, J25.3, L1.1
unnamed: J3.R, J3.RN, J4.4, J26.1, L3.1
unnamed: J3.T, J3.TN, J4.5, J26.3, L2.1
unnamed: J19.T, J27.52 (out_L)
unnamed: J20.T, J27.48 (out_R)
unnamed: J28.3, R20.2
unnamed: JP1.2 (B), U3.12 (GPIO9)
unnamed: JP2.2 (B), U3.11 (GPIO8)
unnamed: J19.SN, JP3.1 (A)
unnamed: J22.SN, JP4.1 (A)
unnamed: J27.47 (out_5V), JP5.1 (A)
unnamed: J20.R, JP5.2 (B)
unnamed: J27.51 (out_5V), JP6.1 (A)
unnamed: J19.R, JP6.2 (B)
unnamed: L2.2, R5.1
unnamed: L3.2, R4.2
unnamed: L4.2, R3.1
unnamed: R7.2, U1.1 (A)
unnamed: R20.1, U1.4 (Y)
unnamed: R21.1, U3.13 (GPIO10)
unnamed: SW4.2, U3.26 (RUN)
unnamed: R10.2, U3.46 (USB_DM)
unnamed: R6.2, U3.47 (USB_DP)
unnamed: C30.2, U6.1 (BST)
unnamed: C34.1, R14.1, U6.6 (COMP)
unnamed: C29.2, R12.2, R15.1, U6.5 (FB)
unnamed: C35.1, U6.4 (SS)
unnamed: R28.1, U9.25 (HS_IND/CFG_SEL1)
unnamed: R24.1, U9.35 (RBIAS)
unnamed: R25.1, U9.24 (SCL/SMBCLK/CFG_SEL0)
unnamed: R26.1, U9.22 (SDA/SMBDATA/NON_REM1)
unnamed: R27.1, U9.28 (SUSP_IND/LOCAL_PWR/NON_REM0)
unnamed: C11.1, U9.33 (XTALIN/CLKIN), Y1.1
unnamed: C25.1, U9.32 (XTALOUT), Y1.2
unnamed: U9.12 (PRTPWR1/BC_EN1), U10.3 (EN)
unnamed: R29.2, U10.5 (ILIM)
